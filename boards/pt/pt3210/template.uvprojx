# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT3210-Hxxx PTW
  pack: PTW.PT3210.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin --output ".\output\@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99 --thumb -c --bss_threshold=0  --diag_suppress=1
  c include: ..\platform\core;..\platform\core\reg;..\platform\drvs\includes;..\platform
  library: MicroLIB
  scatter file: .\link.sct
  group core
    ./: startup.s
  group drvs
    ../platform/drvs/src/: sys.c rcc.c drv_gpio.c drv_uart.c
  group src
    ./: main.c
